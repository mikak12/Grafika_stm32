# Keil uVision project Pierwszy.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pierwszy
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM and STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c GUI_SingleThread.c FramewinDLG.c WindowDLG.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, USB:CORE 6.13.7, Board Support:LED 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:SPI 2.00, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:DMA2D 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:LTDC 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:Startup 2.1.0, Graphics Display:STM32F429I-Discovery 1.0.0, Graphics:CORE 5.50.0, Graphics:Tools:GUI Builder 5.50.0
